** sch_path: cace/templates/voltgen_noise_tb.sch
**.subckt voltgen_noise_tb
**** begin user architecture code

.option savecurrents
.option TEMP=CACE{temperature}

*** GF180MCU model setup.  This is NOT a renaming of the IHP lines it
*** replaces:  IHP ships one .lib file per device class (cornerMOShv,
*** cornerMOSlv, cornerRES ...), while GF180MCU puts every device class
*** in sm141064.ngspice as a named section, so the file is the same each
*** time and only the section changes.
***
*** design.ngspice must come FIRST and is easy to miss:  it defines
*** sw_stat_global, sw_stat_mismatch, mc_skew and fnoicor, which the
*** model sections reference over a hundred times but do not define
*** themselves.  Without it every model evaluates against undefined
*** parameters.
***
*** There is also no separate hv/lv MOS library here;  the one MOS
*** section covers the 3.3 V and the 5/6 V devices together.
***
*** CORNER COVERAGE IS NOT WHAT IT LOOKS LIKE.  The MOS sections
*** typical, ss, ff, sf and fs each skew ONLY the 03v3 devices;  all
*** five pull nfet_06v0_t and pfet_06v0_t, the TYPICAL 6 V models,
*** because no skewed 6 V models exist in this PDK.  So every 5/6 V
*** device in this block is at typical in every corner, and any part of
*** voltgen built from them does not move across the corner axis at all.
*** Keep that in mind when reading a corner sweep that looks suspiciously
*** flat:  it is the PDK, not the circuit.
.include CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/design.ngspice
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/sm141064.ngspice CACE{corner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/sm141064.ngspice diode_CACE{corner_dio}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/sm141064.ngspice res_CACE{corner_res}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/sm141064.ngspice mimcap_CACE{corner_cap}

.include CACE{PDK_ROOT}/CACE{PDK}/libs.ref/gf180mcu_as_sc_mcu7t3v3/spice/gf180mcu_as_sc_mcu7t3v3.spice

*** The DUT.  CACE netlists it separately (schematic, layout, pex or
*** rcx, per --source) and only copies the SYMBOL into the run
*** directory, so xschem cannot expand it here and the instance line
*** would otherwise reference an unknown subckt.
.include CACE{DUT_path}

*** SCOPE:  this characterises the BUFFERED output only.
***
*** voltgen contains one output buffer, the low-power folded cascode on
*** vout_buf.  The high-drive class-AB buffer is a separate cell that
*** sits beside it in chipalooza_frame and is characterised with the
*** frame, not here.  vout_unbuf is brought out for that buffer to use;
*** it is the bare resistor tap, outside the feedback loop, so loading
*** it is an uncorrected error and nothing here loads it.

Vvss  vss  0    DC 0
Vdvss dvss 0    DC 0
Vvdd  vdd  vss  DC CACE{Vdd}
Vdvdd dvdd dvss DC CACE{Vdvdd}

*** Ideal reference, so the block is specified independently of the
*** bandgap.  Note it does not REJECT its reference, it scales it:
*** vout = (s+1)*vbg/(4-high), a gain of 0.25 to 2.67, so bandgap noise
*** and supply rejection are multiplied by up to 8.5 dB on the way to a
*** user project.  These numbers are the buffer, not the delivered bias.
Vvbg  vbg  vss  DC CACE{Vbg} AC 1

*** ibias1u_1 SOURCES into the feedback amplifier;  ibias1u_2 sinks from
*** the cascode buffer.  Separate conditions so a disabled buffer can
*** have its bias removed, which is the documented usage.
I1 vss       ibias1u_1 DC CACE{Ibias}
I2 ibias1u_2 vss       DC CACE{Ibias2}

*** Enables are SENSE-POSITIVE:  a high level enables.  Each amplifier
*** is disabled by a shunt pFET that pulls its bias node to vdd, which
*** is why a disabled amplifier must also have its bias current removed
*** -- otherwise the current source fights the shunt.
Vena  ena  dvss DC CACE[CACE{Vdvdd} * CACE{Ena}]
Vena1 ena1 dvss DC CACE[CACE{Vdvdd} * CACE{Ena1}]
Vena2 ena2 dvss DC CACE[CACE{Vdvdd} * CACE{Ena2}]
Vhigh high dvss DC CACE[CACE{Vdvdd} * CACE{high}]

*** s[2:0] is binary;  bracket expressions permit + - * / % ** and bare
*** math calls only, so each bit is extracted with % and divide.
Vs0 s[0] dvss DC CACE[CACE{Vdvdd} * (CACE{s} % 2)]
Vs1 s[1] dvss DC CACE[CACE{Vdvdd} * (((CACE{s} - (CACE{s} % 2)) / 2) % 2)]
Vs2 s[2] dvss DC CACE[CACE{Vdvdd} * (((CACE{s} - (CACE{s} % 4)) / 4) % 2)]

Cl    vout_buf vss CACE{Cload}
Iload vout_buf vss DC 0

Xdut dvdd dvss vdd s[2] s[1] s[0] vbg vss ibias1u_1 vout_buf ibias1u_2 ena  vout_unbuf ena1 ena2
+ high vgen_ena2_h gf180mcu_ocd_ip__voltgen

.control
save all
*** TWO THINGS HAD TO BE TRUE FOR THIS TO RETURN NUMBERS.
***
*** First, the input source needs an AC value;  see supplies_acbg above.
*** Without it the analysis aborts and leaves an empty .data file.
***
*** Second, the devices have to contribute noise at all.  In IHP every
*** MOSFET is psp103va and every resistor r3_cmc, both Verilog-A loaded
*** as OSDI, and ngspice 44 gets no noise contribution from an OSDI
*** device -- a noise run there produced contribution vectors for the
*** diodes only.  GF180MCU ships native BSIM .model cards for the
*** MOSFETs and native r models for ppolyf_u, so the transistors and the
*** resistor chain both contribute.  The corner sections also pull in
*** noise_corner, which carries the flicker parameters.
***
*** Spot values are taken by INDEX, not by meas:  meas rejects a noise
*** plot outright.  With dec 20 from 0.1 Hz, point i is at
*** 0.1 * 10**(i/20) Hz, so 10 Hz is index 40 and 1 kHz index 80.
noise v(vout_buf) Vvbg dec 20 0.1 10meg 1
setplot noise1
let n_10Hz_VrtHz = onoise_spectrum[40]
let n_1kHz_VrtHz = onoise_spectrum[80]
setplot noise2
let ntot_Vrms = onoise_total
echo $&noise1.n_10Hz_VrtHz $&noise1.n_1kHz_VrtHz $&noise2.ntot_Vrms > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.end
